# IAR project stm32_f107_boot.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F107VC ST STM32F107VC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F10X_CL; USE_STDPERIPH_DRIVER; DEBUG_EN; BOOT_PRJ
  ICCARM.CCIncludePath2: ..\..\src\lib\ST\inc; ..\..\src\app; ..\..\src\bsp; ..\..\src\driver; ..\..\src\lib; ..\..\src\os\ucos\uC-LIB; ..\..\src\os; ..\..\src\os\ucos\uC-LIB; ..\..\src\os\ucos\uCOS-III\Source\; ..\..\src\os\ucos\cfg\; ..\..\src\os\ucos\uC-CPU\ARM-Cortex-M3\IAR; ..\..\src\os\ucos\uC-CPU\; ..\..\src\os\ucos\uCOS-III\Ports\ARM-Cortex-M3\Generic\IAR\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: stm32_f107_boot.srec
  ILINK.IlinkOutputFile: stm32_f107_boot.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group app
    ../../src/app/: main.c
  group app/iap
    ../../src/app/iap/: iap.c
  group bsp
    ../../src/bsp/: bsp.c bsp.h common.h
  group bsp/nRF24L01
    ../../src/bsp/nrf24l01/: cfg.h cmd.h nrf24l01.c nrf24l01.h reg.h
  group driver
    ../../src/driver/: driver.c
  group driver/dma
    ../../src/driver/dma/: dma.c
  group driver/exti
    ../../src/driver/exti/: exti.c
  group driver/gpio
    ../../src/driver/gpio/: gpio.c gpio.h
  group driver/interrupt
    ../../src/driver/interrupt/: interrupt.c
  group driver/log
    ../../src/driver/log/: log.c
  group driver/rcc
    ../../src/driver/rcc/: rcc.c
  group driver/spi
    ../../src/driver/spi/: spi.c
  group driver/usart
    ../../src/driver/usart/: usart.c
  group lib/ARM
    ../../src/lib/CMSIS/CM3/CoreSupport/: core_cm3.c core_cm3.h
    ../../src/lib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_cl.s
  group lib/ST
    ../../src/lib/ST/src/: stm32f10x_it.c stm32f10x_rcc.c system_stm32f10x.c
  group os/ucos
    ../../src/os/ucos/uC-CPU/ARM-Cortex-M3/IAR/: cpu_a.asm
