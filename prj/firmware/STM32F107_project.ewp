# IAR project STM32F107_project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F107VC ST STM32F107VC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F10X_CL; USE_STDPERIPH_DRIVER; DEBUG_EN
  ICCARM.CCIncludePath2: ..\..\src\lib\ST\inc; ..\..\src\app; ..\..\src\bsp; ..\..\src\driver; ..\..\src\lib; ..\..\src\os\ucos\uC-LIB; ..\..\src\os; ..\..\src\os\ucos\uC-LIB; ..\..\src\os\ucos\uCOS-III\Source\; ..\..\src\os\ucos\cfg\; ..\..\src\os\ucos\uC-CPU\ARM-Cortex-M3\IAR; ..\..\src\os\ucos\uC-CPU\; ..\..\src\os\ucos\uCOS-III\Ports\ARM-Cortex-M3\Generic\IAR\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32F107_project.sim
  ILINK.IlinkOutputFile: STM32F107_project.elf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group app
    ../../src/app/: main.c
  group bsp
    ../../src/bsp/: bsp.c
  group bsp/nRF24L01
    ../../src/bsp/nrf24l01/: nrf24l01.c
  group driver
    ../../src/driver/: driver.c
  group driver/dma
    ../../src/driver/dma/: dma.c
  group driver/exti
    ../../src/driver/exti/: exti.c
  group driver/gpio
    ../../src/driver/gpio/: gpio.c
  group driver/interrpt
    ../../src/driver/interrupt/: interrupt.c
  group driver/log
    ../../src/driver/log/: log.c
  group driver/rcc
    ../../src/driver/rcc/: rcc.c
  group driver/spi
    ../../src/driver/spi/: spi.c
  group driver/usart
    ../../src/driver/usart/: usart.c
  group lib/ARM
    ../../src/lib/CMSIS/CM3/CoreSupport/: core_cm3.c core_cm3.h
    ../../src/lib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_cl.s
  group lib/ST
    ../../src/lib/ST/src/: stm32f10x_it.c stm32f10x_rcc.c system_stm32f10x.c
  group os
    ../../src/os/: os.c
  group os/ucos/Bsp
    ../../src/os/ucos/Bsp/: os_bsp.c
  group os/ucos/Task
    ../../src/os/ucos/Task/: task.c
  group os/ucos/uC-CPU
    ../../src/os/ucos/uC-CPU/: cpu_core.c cpu_core.h cpu_def.h
  group os/ucos/uC-CPU/ARM-Cortex-M3
    ../../src/os/ucos/uC-CPU/ARM-Cortex-M3/IAR/: cpu.h cpu_a.asm cpu_c.c
  group os/ucos/uC-LIB
    ../../src/os/ucos/uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
  group os/ucos/uC-LIB/Ports/ARM-Cortex-M3
    ../../src/os/ucos/uC-LIB/Ports/ARM-Cortex-M3/IAR/: lib_mem_a.asm
  group os/ucos/uCOS-III/Ports/ARM-Cortex-M3/Generic
    ../../src/os/ucos/uCOS-III/Ports/ARM-Cortex-M3/Generic/IAR/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group os/ucos/uCOS-III/Source
    ../../src/os/ucos/uCOS-III/Source/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_type.h os_var.c
