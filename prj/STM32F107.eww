<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\boot\stm32_f107_boot.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\firmware\STM32F107_project.ewp</path>
  </project>
  <batchBuild/>
</workspace>


